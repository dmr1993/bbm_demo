# Keil uVision project AppDemo.uvproj, settings and files
target LKT5103A (ARM-ADS)
  device: LKT5103A Link Coresafe ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LKT5103A_AppDemo +hex
  c flags: Optim=4
  c include: ..\head
  asm include: ..\..\SRC\HAL\ARM_FLASH\REG
  scatter file: .\ARM_APP.sc
  group Source
    ../src/: App_Main.c start.s App_fun.c
    ../Lib/: LKAPI_5103A.lib
